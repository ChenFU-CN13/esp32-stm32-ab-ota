# Keil uVision project LVGL_RTOS_DOME5.uvprojx, settings and files
target LVGL_RTOS_DOME5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: LVGL_RTOS_DOME5
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Drivers;..\LVGL;..\LVGL\examples\porting;..\LVGL\src;..\LVGL\demos;..\LVGL\demos\music;..\LVGL\demos\widgets;..\LVGL\myGUI\custom;..\LVGL\myGUI\generated;..\LVGL\myGUI\generated\guider_fonts;..\Drivers\Module_driver\inc;..\LVGL\myGUI\generated\guider_customer_fonts
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c uart2_ringbuf.c uart2_comm.c DMA_LCD.c APP_Tasks.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_spi.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/SYSTEM
    ../Drivers/SYSTEM/delay/: delay.c
    ../Drivers/SYSTEM/sys/: sys.c
    ../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../Drivers/BSP/24CXX/: 24cxx.c
    ../Drivers/BSP/IIC/: myiic.c
    ../Drivers/BSP/KEY/: key.c
    ../Drivers/BSP/LCD/: lcd.c
    ../Drivers/BSP/LED/: led.c
    ../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../Drivers/BSP/TIMER/: btim.c
    ../Drivers/BSP/SRAM/: sram.c
  group LVGL_conf
    ../LVGL/: lv_conf.h lvgl.h
  group LVGL_porting
    ../LVGL/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group LVGL_src
    ../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../LVGL/src/draw/renesas/: lv_gpu_d2_ra6m3.c lv_gpu_d2_draw_label.c
    ../LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../LVGL/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../LVGL/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/src/extra/others/msg/: lv_msg.c
    ../LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/src/extra/widgets/led/: lv_led.c
    ../LVGL/src/extra/widgets/list/: lv_list.c
    ../LVGL/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/src/extra/widgets/span/: lv_span.c
    ../LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/src/extra/widgets/win/: lv_win.c
    ../LVGL/src/extra/: lv_extra.c
    ../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_domes_music
    ../LVGL/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../LVGL/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group LVGL_domes_wights
    ../LVGL/demos/widgets/: lv_demo_widgets.c
    ../LVGL/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group LVGL_myGui
    ../LVGL/myGUI/generated/: events_init.c gui_guider.c setup_scr_screen.c setup_scr_screen_setting.c widgets_init.c
    ../LVGL/myGUI/generated/images/: _1_alpha_40x40.c _7_alpha_40x40.c _8_alpha_40x40.c _9_alpha_40x40.c _addmeteo_alpha_40x40.c _hum_alpha_40x40.c _icon_alpha_40x40.c _jia_alpha_35x35.c _jian_alpha_35x35.c _log_alpha_123x122.c _meun1_5_alpha_60x60.c _t1_alpha_50x50.c _temp1_alpha_40x40.c _WiFi_alpha_40x40.c
    ../LVGL/myGUI/generated/guider_fonts/: lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_SourceHanSerifSC_Regular_16.c lv_font_SourceHanSerifSC_Regular_18.c lv_font_SourceHanSerifSC_Regular_19.c lv_font_SourceHanSerifSC_Regular_20.c lv_font_SourceHanSerifSC_Regular_30.c
  group Module_driver
    ../Drivers/Module_driver/src/: buzzer.c DTH11.c FAN.c
software components: CMSIS:CORE 5.5.0
